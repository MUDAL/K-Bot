# Keil uVision project K_Bot.uvprojx, settings and files
target stm32f103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: K_Bot
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./: main.c main.h
  group High Level Lib
    ./: bluetooth.c bluetooth.h system.c system.h outputDev.c outputDev.h
  group Low Level Lib
    ./: clock.c clock.h dma.c dma.h gpio.c gpio.h i2c.c i2c.h uart.c uart.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
